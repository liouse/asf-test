# IAR project i2c_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20J18 Atmel ATSAMD20J18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: SYSTICK_MODE; I2C_SLAVE_CALLBACK_MODE=true; BOARD=SAMD20_XPLAINED_PRO; _ASSERT_ENABLE_; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; __SAMD20J18__; I2C_MASTER_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../system/clock/clock_samd20; ../../../../../system/power; ../../../../../system/reset; ../../../../../../utils/preprocessor; ../..; ../../../../../../boards/samd20_xplained_pro; ../../../../../../utils/cmsis/samd20/source; ../../../../../../../common2/services/delay; ../../../../../../utils; ../../../..; ../../../../../port; ../../../../../../boards; ../../../../usart; ../../../../../../../common/services/serial; ../../../../../../../common2/services/delay/sam0; ../../..; ../../../../../system/reset/reset_sam_d_r_h; ../../../../../../../common/utils; ..; ../../../../../system/interrupt/system_interrupt_samd20; ../../../../../system/interrupt; ../../../i2c_samd20; ../../../../../system/power/power_sam_d_r_h; ../../../../../../../common/boards; ../../../../../../utils/cmsis/samd20/include; ../../../../../system/pinmux; ../../../../../system; ../../../../../../utils/header_files; ../../../../../../utils/stdio/stdio_serial; ../../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: i2c_unit_test_flash.bin
  ILINK.IlinkOutputFile: i2c_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/boards
    ../../../../../../../common/boards/: board.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../../boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../: sercom.c sercom.h sercom_interrupt.c sercom_interrupt.h sercom_pinout.h
  group sam0/drivers/sercom/i2c
    ../../../: i2c_common.h i2c_master.h i2c_master_interrupt.h i2c_slave.h i2c_slave_interrupt.h
  group sam0/drivers/sercom/i2c/i2c_samd20
    ../../../i2c_samd20/: i2c_master.c i2c_master_interrupt.c i2c_slave.c i2c_slave_interrupt.c
  group sam0/drivers/sercom/i2c/quick_start_master
    ../../../quick_start_master/: qs_i2c_master_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_master_callback
    ../../../quick_start_master_callback/: qs_i2c_master_callback.h
  group sam0/drivers/sercom/i2c/quick_start_master_dma
    ../../../quick_start_master_dma/: qs_i2c_master_dma.h
  group sam0/drivers/sercom/i2c/quick_start_slave
    ../../../quick_start_slave/: qs_i2c_slave_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_slave_callback
    ../../../quick_start_slave_callback/: qs_i2c_slave_callback.h
  group sam0/drivers/sercom/i2c/quick_start_slave_dma
    ../../../quick_start_slave_dma/: qs_i2c_slave_dma.h
  group sam0/drivers/sercom/i2c/unit_test
    ../../: unit_test.c
  group sam0/drivers/sercom/i2c/unit_test/samd20j18_samd20_xplained_pro
    ../: conf_board.h conf_clocks.h conf_test.h
  group sam0/drivers/sercom/i2c/unit_test/samd20j18_samd20_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/sercom/usart
    ../../../../usart/: usart.c usart.h usart_interrupt.c usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/system
    ../../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../../system/clock/clock_samd20/: clock.c clock_config_check.h clock_feature.h gclk.c
  group sam0/drivers/system/interrupt
    ../../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../../system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../system/reset/reset_sam_d_r_h/: reset.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd20/include
    ../../../../../../utils/cmsis/samd20/include/: samd20.h samd20e14.h samd20e15.h samd20e16.h samd20e17.h samd20e18.h samd20g14.h samd20g15.h samd20g16.h samd20g17.h samd20g17u.h samd20g18.h samd20g18u.h samd20j14.h samd20j15.h samd20j16.h samd20j17.h samd20j18.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../../utils/cmsis/samd20/include/component/: ac.h adc.h dac.h dsu.h eic.h evsys.h gclk.h nvmctrl.h pac.h pm.h port.h rtc.h sercom.h sysctrl.h tc.h wdt.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../../utils/cmsis/samd20/include/instance/: ac.h adc.h dac.h dsu.h eic.h evsys.h gclk.h nvmctrl.h pac0.h pac1.h pac2.h pm.h port.h rtc.h sercom0.h sercom1.h sercom2.h sercom3.h sercom4.h sercom5.h sysctrl.h tc0.h tc1.h tc2.h tc3.h tc4.h tc5.h tc6.h tc7.h wdt.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../../utils/cmsis/samd20/include/pio/: samd20e14.h samd20e15.h samd20e16.h samd20e17.h samd20e18.h samd20g14.h samd20g15.h samd20g16.h samd20g17.h samd20g17u.h samd20g18.h samd20g18u.h samd20j14.h samd20j15.h samd20j16.h samd20j17.h samd20j18.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../../utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../../utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: mrecursion.h mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam0/utils/stdio
    ../../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
